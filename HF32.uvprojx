# Keil uVision project HF32.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: AM32 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER
  c include: .\mcu\F421\CMSIS\CM4\CoreSupport;.\mcu\F421\CMSIS\CM4\DeviceSupport;.\mcu\F421\AT32F421_StdPeriph_Driver\inc;.\Inc;.\mcu\F421\mcuinc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Objects\Am32.sct
  group CMSIS
    ./mcu/F421/CMSIS/CM4/DeviceSupport/: system_at32f421.c
    ./mcu/F421/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f421.s
  group Src
    ./Src/: main.c eeprom.c ADC.c comparator.c dshot.c functions.c IO.c phaseouts.c signal.c sounds.c firmwareversion.c
  group F4_Std
    ./mcu/F421/AT32F421_StdPeriph_Driver/src/: at32f421_adc.c at32f421_cmp.c at32f421_crc.c at32f421_crm.c at32f421_debug.c at32f421_dma.c at32f421_ertc.c at32f421_exint.c at32f421_flash.c at32f421_gpio.c at32f421_i2c.c at32f421_misc.c at32f421_pwc.c at32f421_scfg.c at32f421_spi.c at32f421_tmr.c at32f421_usart.c at32f421_wdt.c at32f421_wwdt.c
  group F421
    ./mcu/F421/mcusrc/: at32f421_it.c peripherals.c serial_telemetry.c
target AT32DEV_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.0
  cpu: as above
  output: AM32_AT32DEV_F421 +hex
  AfterMake: ./tools/srec_cat.exe ./Objects/eepdefault.hex -Intel ./Objects/Am32bootloaderpb4.hex -Intel ./Objects/@L.hex -Intel -o ./Objects/@L_merged.hex -Intel
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, AT32DEV_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Objects\Am32.sct
target AT32ADC_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.0
  cpu: as above
  output: AM32_AT32ADC_F421 +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, AT32ADC_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Objects\Am32.sct
target NEUTRONRC_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.0
  cpu: as above
  output: HF32_NeutronRC_F421 +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, NEUTRONRC_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Objects\Am32.sct
target NEUTRONRC_IH_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.0
  cpu: as above
  output: AM32_NeutronRC_IH_F421 +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, NEUTRONRC_IH_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Objects\Am32.sct
target AT32DEV_F421_540 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.0
  cpu: as above
  output: HF32_AT32DEV_F421_540 +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, AT32DEV_F421_540
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Objects\Am32.sct
target TEKKO32_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.0
  cpu: as above
  output: AM32_TEKKO32_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, TEKKO32_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Objects\Am32.sct
target FOXEER (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.0
  cpu: as above
  output: AM32_FOXEER_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, FOXEER_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Objects\Am32.sct
target AIKON_SINGLE (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.0
  cpu: as above
  output: AM32_AIKON_S_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, AIKON_S_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Objects\Am32.sct
target AIKON_55A (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.0
  cpu: as above
  output: AM32_AIKON_55A_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, AIKON_55A_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Objects\Am32.sct
target WRAITH32 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.0
  cpu: as above
  output: AM32_WRAITH32_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, WRAITH32_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Objects\Am32.sct
target HAKRC_KB (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.0
  cpu: as above
  output: AM32_HAKRC_K_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, HAKRC_K_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Objects\Am32.sct
target HAKRC_GB (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.0
  cpu: as above
  output: AM32_HAKRC_G_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, HAKRC_G_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Objects\Am32.sct
